RDEPENDS_libgl-imx-dev_remove = "libgl-mesa-dev"
RDEPENDS_libgl-imx-dev += "libgl-dev"
