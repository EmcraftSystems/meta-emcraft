# Copyright (C) 2018 Emcraft Systems
#
# Qt5 Emcraft Demo project
#
# Pre-packaged version

require qt5-emcraft-demo.inc

SRC_URI = "file://qt5-emcraft-demo.tar.gz"
SRC_URI += "file://qt5-emcraft-demo.service"
S="${WORKDIR}/"
