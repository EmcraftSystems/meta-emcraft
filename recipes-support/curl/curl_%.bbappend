PACKAGECONFIG_append_pn-curl = " ssl nghttp2"
