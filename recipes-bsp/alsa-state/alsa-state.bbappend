# Copyright (C) 2018 Emcraft Systems
FILESEXTRAPATHS_prepend_mx8 := "${THISDIR}/${PN}/imx:"
PACKAGE_ARCH_mx8 = "${MACHINE_ARCH}"
