FILESEXTRAPATHS_prepend := "${THISDIR}/:"
SRC_URI += "file://atf_add_m4_stop.patch"
