require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "37679b0d4075c2fdfa2a2795d3cd9e24"
SRC_URI[sha256sum] = "5abe12cb0b686edcbb5848d4dfb79127c4b683832a6b9d32378f071c03d114ef"

COMPATIBLE_MACHINE = "(mx8)"
