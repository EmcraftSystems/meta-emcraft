RDEPENDS_${PN}_append = " \
        libopencl-imx \
        libclc-imx-dev \
	devil-dev \
" 
