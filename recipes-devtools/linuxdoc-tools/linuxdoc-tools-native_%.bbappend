FILESEXTRAPATHS_prepend := "${THISDIR}/linuxdoc-tools:"
SRC_URI_append = " file://unescaped-f27.patch"
