FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://gcc8-fix.patch"
