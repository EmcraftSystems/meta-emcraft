FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://bison-3.0.5-gnulib-fseterr.patch"
