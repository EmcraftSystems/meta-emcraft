SRC_URI_remove = "git://git.alsa-project.org/tinycompress.git;protocol=git;branch=master"
SRC_URI += "git://git.alsa-project.org/http/tinycompress.git;protocol=http;branch=master"
